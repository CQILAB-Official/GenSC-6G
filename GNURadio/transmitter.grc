options:
  parameters:
    generate_options: qt_gui
    id: tes
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, 1, length_tag_key)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: '[[-26, -25, -24, -23, -22, -20, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10, -9, -8, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 22, 23, 24, 25, 26]]'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '96'
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/briancqi/HackRF/received_data.bin
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/briancqi/HackRF/received_data.bin
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/briancqi/HackRF/transmit_data.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/briancqi/HackRF/text_file.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: '96'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '1000000'
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 1e6
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 1e6
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: '1000000'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: ''
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: length_tag_key
    packed: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: length_tag_key
    packed: 'True'
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '16'
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: header_formatter.formatter()
    len_tag_key: '"packet_len"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: header_bits
  id: virtual_sink
  parameters:
    stream_id: Header Bits
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '1000000'
    fc: '915000000'
    fftsize: '1024'
    plotfreq: 'False'
    rate: '500'
    type: complex
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: '915000000'
    dev_args: serial=0000000000000000d63861dc2a4e7153
    samp_rate: '1000000'
    type: fc32
    vga: '40'
  states: {state: disabled}
- name: soapy_hackrf_sink_0_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: '2400000000'
    dev_args: serial=0000000000000000d63861dc2a4e7153
    samp_rate: '1000000'
    type: fc32
    vga: '47'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: '915000000'
    dev_args: serial=0000000000000000d63861dc2a6cab53
    gain: '40'
    samp_rate: 1e6
    type: fc32
    vga: '30'
  states: {state: disabled}
- name: soapy_hackrf_source_0_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: '2400000000'
    dev_args: serial=0000000000000000d63861dc2a6cab53
    gain: '40'
    samp_rate: 1e6
    type: fc32
    vga: '30'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Time Domain
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Bits
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Time Domain
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_throttle_0_1, '0']
- [blocks_repack_bits_bb_0, '0', header_bits, '0']
- [blocks_stream_mux_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_throttle_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_throttle_0_1, '0', soapy_hackrf_sink_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', virtual_sink_0_0_0, '0']
- [digital_crc32_bb_0_0, '0', digital_packet_headergenerator_bb_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [digital_packet_headergenerator_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [soapy_hackrf_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [soapy_hackrf_source_0_0, '0', blocks_throttle_0_0_0, '0']
- [virtual_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_multiply_const_vxx_0_1, '0']

metadata:
  file_format: 1
